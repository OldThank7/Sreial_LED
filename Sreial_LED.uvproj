# Keil uVision project Sreial_LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Sreial_LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib\INC;.\Lib\INC\STC
  group user
    ./: Sreial_LED.c
